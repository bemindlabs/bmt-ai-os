DESCRIPTION = "Drivers for NPU/GPU AI acceleration on ARM"
LICENSE = "CLOSED"
SRC_URI = "file://npu-drivers.tar.gz"