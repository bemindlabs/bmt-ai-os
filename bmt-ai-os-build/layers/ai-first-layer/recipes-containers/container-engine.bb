IMAGE_INSTALL:append = " containerd docker-cli "
KERNEL_FEATURES:append = " cgroups namespaces "